# Keil uVision project keil.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F040 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: keil +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\KEIL
  group Source Group 1
    ./: STARTUP.A51 CAN2.c CAN3.c myconfig.c zk.c UART1.C record.txt
